# IAR project mstimer.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC3250 NXP LPC3250
  ICCARM.CCIncludePath2: \nxpmcu\software\lpc\include\; \nxpmcu\software\csps/lpc32xx\include; \nxpmcu\software\csps/lpc32xx\bsps\phy3250\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: mstimer.sre
  ILINK.IlinkOutputFile: mstimer.out
  ILINK.IlinkIcfFile: mstimer.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../common/: main_iar.c
    ../: mstimer_example.c
  group BSP
    ../../../source/: phy3250_board.c phy3250_nand.c
    ../../../include/: phy3250_board.h phy3250_nand.h
  group Common
    ../../../../../../../lpc/include/: lpc_ac97_codec.h lpc_api.h lpc_arm922t_arch.h lpc_arm922t_cp15_driver.h lpc_arm_arch.h lpc_bmp.h lpc_cf_card.h lpc_colors.h lpc_fat16.h lpc_fat16_private.h lpc_fat_fs.h lpc_fonts.h lpc_heap.h lpc_helvr10.h lpc_irq_fiq.h lpc_lbecc.h lpc_lcd_params.h lpc_line_parser.h lpc_nandflash_params.h lpc_params.h lpc_ring.h lpc_rom8x16.h lpc_rom8x8.h lpc_sdmmc.h lpc_string.h lpc_swim.h lpc_swim_font.h lpc_swim_image.h lpc_types.h lpc_wave.h lpc_winfreesystem14x16.h lpc_x5x7.h lpc_x6x13.h
    ../../../../../../../lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x16.c lpc_rom8x8.c lpc_string.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
  group CSP
    ../../../../../source/: lpc32xx_adc_driver.c lpc32xx_clcdc_driver.c lpc32xx_clkpwr_driver.c lpc32xx_dma_driver.c lpc32xx_gpio_driver.c lpc32xx_hstimer_driver.c lpc32xx_hsuart_driver.c lpc32xx_i2c_driver.c lpc32xx_i2s_driver.c lpc32xx_intc_driver.c lpc32xx_kscan_driver.c lpc32xx_mlcnand_driver.c lpc32xx_mstimer_driver.c lpc32xx_pwm_driver.c lpc32xx_rtc_driver.c lpc32xx_sdcard_driver.c lpc32xx_slcnand_driver.c lpc32xx_spi_driver.c lpc32xx_ssp_driver.c lpc32xx_timer_driver.c lpc32xx_tsc_driver.c lpc32xx_uart_driver.c lpc32xx_vectors.s79 lpc32xx_wdt_driver.c lpc3xxx_spwm_driver.c
    ../../../../../include/: lpc32xx_adc_driver.h lpc32xx_chip.h lpc32xx_clcdc.h lpc32xx_clcdc_driver.h lpc32xx_clkpwr.h lpc32xx_clkpwr_driver.h lpc32xx_dma_driver.h lpc32xx_dmac.h lpc32xx_emc.h lpc32xx_gpio.h lpc32xx_gpio_driver.h lpc32xx_hstimer.h lpc32xx_hstimer_driver.h lpc32xx_hsuart.h lpc32xx_hsuart_driver.h lpc32xx_i2c.h lpc32xx_i2c_driver.h lpc32xx_i2s.h lpc32xx_i2s_driver.h lpc32xx_intc.h lpc32xx_intc_driver.h lpc32xx_kscan.h lpc32xx_kscan_driver.h lpc32xx_mac.h lpc32xx_mlcnand.h lpc32xx_mlcnand_driver.h lpc32xx_mstimer.h lpc32xx_mstimer_driver.h lpc32xx_otg.h lpc32xx_pwm.h lpc32xx_pwm_driver.h lpc32xx_rtc.h lpc32xx_rtc_driver.h lpc32xx_sdcard.h lpc32xx_sdcard_driver.h lpc32xx_slcnand.h lpc32xx_slcnand_driver.h lpc32xx_smplpwm.h lpc32xx_spi.h lpc32xx_spi_driver.h lpc32xx_ssp.h lpc32xx_ssp_driver.h lpc32xx_timer.h lpc32xx_timer_driver.h lpc32xx_tsc.h lpc32xx_tsc_driver.h lpc32xx_uart.h lpc32xx_uart_driver.h lpc32xx_wdt.h lpc32xx_wdt_driver.h lpc3xxx_spwm.h lpc3xxx_spwm_driver.h
